## config/Kconfig.defconfig
```kconfig
if GLITCHED38

// name can't be longer than 16 characters
config ZMK_KEYBOARD_NAME
    default "Glitched 38"

endif    
```
